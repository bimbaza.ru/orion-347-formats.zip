Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:19:37+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-GEN-512-0025
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Комплекс игровой детский, ZSK-GEN-512-0025 Игровой комплекс «Пузырьковая Башня»
In: Площадка
Description: Комплекс игровой детский. Игровой комплекс «Пузырьковая Башня»; Classification: 59.1.15.01-0532 Комплекс игровой (Классификатор строительных ресурсов (КСР)); Material: Нержавеющая сталь, атмосферостойкий HDPE, армированные канат
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-GEN-512-0025; ModelReference: Игровой комплекс «Пузырьковая Башня»; ProductionYear: 2026; ArticleNumber: ZSK-GEN-512-0025
ORION_Изделие - Артикул: ZSK-GEN-512-0025; Артикул прежний: SD-GEN-512-0025; Наименование: Игровой комплекс «Пузырьковая Башня»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 7.6 x 5.5 м; Зона безопасности: 11.3 x 9.1 м; Высота свободного падения: 1.8 м; Возраст: для детей от 2 до 12 лет; Материал: Нержавеющая сталь, атмосферостойкий HDPE, армированные канаты; Цена: 1 500 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/play-complexes/347; Код КСИ: CPr>EDB080; Класс КСИ: Комплекс игровой; Коды КСР: 59.1.15.01-0532 … 59.1.15.01-0595
ADSK - ADSK_Наименование: Игровой комплекс «Пузырьковая Башня»; ADSK_Марка: ZSK-GEN-512-0025; ADSK_Код изделия: 59.1.15.01-0532; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: Нержавеющая сталь, атмосферостойкий HDPE, армированные канаты; ADSK_URL страницы изделия: https://зск.рф/catalog/play-complexes/347
ZSK_Благоустройство - ZSK_Возрастная_группа: для детей от 2 до 12 лет; ZSK_Зона_безопасности: 11.3 x 9.1 м; ZSK_Высота_свободного_падения: 1.8 м; ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDB080; ZSK_Артикул_прежний: SD-GEN-512-0025
Qto_ORION - Длина: 7600 mm; Ширина: 5500 mm; Высота: 0 mm
